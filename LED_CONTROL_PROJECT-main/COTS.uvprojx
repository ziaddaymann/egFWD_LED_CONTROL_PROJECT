# Keil uVision project COTS.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: COTS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/DIO/Config/: Dio_PBcfg.c
    ./MCAL/DIO/inc/: Dio.h Dio_Cfg.h Dio_Regs.h
    ./MCAL/DIO/src/: Dio.c
    ./MCAL/IntCtrl/inc/: IntCtrl.h IntCtrl_Cfg.h IntCtrl_Regs.h
    ./MCAL/IntCtrl/Config/: IntCtrl_PBcfg.c
    ./MCAL/IntCtrl/src/: IntCtrl.c
    ./MCAL/PORT/Config/: Port_PBcfg.c
    ./MCAL/PORT/inc/: Port.h Port_Cfg.h Port_Regs.h
    ./MCAL/PORT/src/: Port.c
    ./MCAL/SYSTICK/inc/: SysTick.h SysTick_Regs.h
    ./MCAL/SYSTICK/src/: SysTick.c
  group HAL
    ./HAL/LED/inc/: Led.h
    ./HAL/LED/src/: Led.c
  group App
    ./App/: main.c
  group LIB
    ./LIB/: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h tm4c123gh6pm_registers.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
